# Keil uVision project Bismillah_Rev2.uvprojx, settings and files
target Bismillah_Rev2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Bismillah_Rev2
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;   D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Drivers/STM32F4xx_HAL_Driver/Inc;   D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;   D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Drivers/CMSIS/Include;   ..\..\Bismillah_Rev2;D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/include;D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c freertos.c stm32f4xx_hal_timebase_TIM.c
    ../Inc/: lcd_txt.c lcd_txt.h
  group Middlewares/FreeRTOS
    D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c timers.c queue.c croutine.c list.c tasks.c
    D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    D:/Psychorobotic/Program/STM32/SOFTWARE/STM32Cube_FW_F4_V1.13.0/STM32Cube_FW_F4_V1.17.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
